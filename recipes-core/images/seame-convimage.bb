SUMMARY = "SEA:ME image"
LICENSE = "MIT"

inherit seameconv_image
